# Keil uVision project SVPE48D.uvproj, settings and files
target SVPE48D (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: SVPE48D +hex
  c flags: Optimize=9
  c define: IN_KEIL
  link misc: REMOVEUNUSED
  group StartUp
    ./Src/: main.c STARTUP.A51 Conf_tny.A51
  group STCLib
    ./Src/STCLib/: ADC.c delay.c EEPROM.c Exti.c GPIO.c PCA.c Soft_UART.c timer.c USART.C
  group Board
    ./Src/Board/: BoardSVPE48D.c LED.c ChipSE0165B.c ChipRTL8306E.c DIPSwitch.c
  group RTLLib
    ./Src/RTLLib/: mdcmdio.c rtk_api.c rtl8306e_asicdrv.c
  group Comm
    ./Src/communication/: command.c console.c dcc.c
  group Business
    ./Src/Business/: Device.c E1Port.c ConfigData.c
